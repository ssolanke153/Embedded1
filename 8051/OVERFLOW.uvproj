# Keil uVision project OVERFLOW.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS89C420 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(50000000) MODDP2
  output: OVERFLOW
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: OVERFLOW.a51
