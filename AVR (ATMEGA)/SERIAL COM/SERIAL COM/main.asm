;
; SERIAL COM.asm
;
; Created: 25-05-2020 11:32:25
; Author : Shri
 

 .INCLUDE "M32DEF.INC"18
 


LDI R21,HIGH(RAMEND)
 OUT SPH ,R21
 LDI R21,LOW(RAMEND)
 OUT SPL ,R21

 LDI R16,(1<<TXEN)
 OUT UCSRB,R16
 LDI R16,(1<<UCSZ1) | (1<<UCSZ0)
 OUT UCSRC,R16
 LDI R16,0x33
 OUT UBRRL,R16

 AGAIN:
    LDI R17,'S'
	CALL TRANSMT
	LDI R17,'H'
	CALL TRANSMT
	LDI R17,'R'
	CALL TRANSMT
	LDI R17,'I'
	CALL TRANSMT
	LDI R17,'K'
	CALL TRANSMT
	LDI R17,'A'
	CALL TRANSMT
	LDI R17,'N'
	CALL TRANSMT
	LDI R17,'T'
	CALL TRANSMT
	RJMP AGAIN

TRANSMT:
    SBIS UCSRA,UDRE
	RJMP TRANSMT
	OUT UDR,R17
	RET

	.EXIT