# Keil uVision project AVR.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: AVR
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BV.a51
