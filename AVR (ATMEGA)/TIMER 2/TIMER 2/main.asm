;
; TIMER 2.asm
;
; Created: 17-05-2020 22:38:03
; Author : Shri


LDI R16,1<<5
LDI R18,0x1D
SBI DDRB,5
LDI R17,0
OUT PORTB,R17

RPT:

MORE:RCALL DELAY
	DEC R18
	BRNE MORE
	EOR R17,R16
    OUT PORTB,R17
     CLZ




	 RJMP RPT

DELAY:	 LDI R20,-256
	 OUT TCNT2,R20
	 LDI R20,0x07
	 OUT TCCR2,R20

RPT1:IN R20,TIFR
	 SBRS R20,TOV2
	 RJMP RPT1
	 LDI R20,0x00
	 OUT TCCR2,R20
	 LDI R20,1<<TOV2
	 OUT TIFR,R20

	 RET

.EXIT 