;
; interrupt_1.asm
;
; Created: 6/3/2020 5:28:34 PM
; Author : Shri
 

.INCLUDE"M32DEF.INC"

SBI DDRD,2
LDI R20, 0x55
AGAIN1:

COM R20
OUT PORTD, R20
RCALL DELAY

RJMP AGAIN1

DELAY:
 LDI R16, 0x00
 OUT TCNT1H,R16
 LDI R16, 0x00
 OUT TCNT1L,R16
 LDI R16,0x00
 OUT TCCR1A, R16
 LDI R16,0x03
 OUT TCCR1B, R16
AGAIN:
 IN R16,TIFR
 SBRS R16,1<<TOV1
 RJMP AGAIN

 LDI R16,0x00
 OUT TCCR1B, R16

 LDI R16,1<<TOV1
 OUT TIFR , R16
 RET

 .EXIT




